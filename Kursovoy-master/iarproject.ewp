# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Rtos; Rtos\wrapper; Rtos\wrapper\FreeRtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable; Rtos\FreeRtos\portable\Common; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\FreeRtos\portable\MemMang; MyTasks; Common; CMSIS; Application; Application\Diagnostic; AHardware; AHardware\GpioPort; AHardware\IrqController; ..\CortexLib-master\AbstractHardware\Pin; ..\CortexLib-master\AbstractHardware\Registers\STM32F411\FieldValues; ..\CortexLib-master\AbstractHardware\Registers\STM32F411; ..\CortexLib-master\AbstractHardware\Registers; ..\CortexLib-master\AbstractHardware\Port; ..\CortexLib-master\AbstractHardware\Atomic; ..\CortexLib-master\Common; ..\CortexLib-master\Common\Singleton
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
    CortexLib-master/Common/: susudefs.hpp
  group AHardware
    AHardware/: ADC.hpp ButtonTask.cpp ButtonTask.hpp MyPin.hpp PWM.hpp USART.hpp USARTConfig.hpp
  group Application
    Application/: Celsius.hpp Fahrenheit.hpp IUnits.hpp IVariable.hpp Kelvin.hpp Temperature.hpp VariableTask.hpp Voltage.hpp
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/portable/Common
    Rtos/FreeRtos/portable/Common/: mpu_wrappers.c
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.c portasm.s
  group Rtos/FreeRtos/portable/MemMang
    Rtos/FreeRtos/portable/MemMang/: heap_1.c
  group Rtos/wrapper
    ../../../Users/User/Documents/1403/RtosWrapper-master/Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
